# Keil uVision project mcu-project.uvprojx, settings and files
target STM32F103C8 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcu-project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\app\inc;..\bsp;..\hal\inc;..\middlewares\CMSIS;..\middlewares\CMSIS\Core;..\middlewares\STM32F10x_StdPeriph_Driver\inc;..\middlewares\FreeRTOS\include;..\middlewares\FreeRTOS\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../: main.c
  group app
    ../app/src/: app_ipc.c app_logic.c app_settings.c task_control.c task_alarm.c task_display.c task_input.c task_sensor.c
  group bsp
    ../bsp/: bsp.c bsp_button.c bsp_ds18b20.c bsp_oled.c bsp_relay.c bsp_uart.c
  group hal
    ../hal/src/: hal_delay.c hal_ds18b20.c hal_gpio.c hal_i2c.c hal_oled.c hal_uart.c
  group CMSIS
    ../middlewares/CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group SPL
    ../middlewares/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS
    ../middlewares/FreeRTOS/: tasks.c queue.c list.c event_groups.c timers.c
    ../middlewares/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../: README.md
